# mjmech image class

FEATURE_PACKAGES_mjmech-deps =" \
  snappy \
  log4cpp \
  gstreamer1.0-rtsp-server \
"

inherit refosiot-image
WKS_FILE = "refosiot.wks.in"
