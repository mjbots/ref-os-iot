PACKAGECONFIG_remove = "theora"
