# Needed in order to satisfy GNU_HASH QA requirement
TARGET_CC_ARCH += "${LDFLAGS}"
